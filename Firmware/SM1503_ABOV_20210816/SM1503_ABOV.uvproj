# Keil uVision project SM1503_ABOV.uvproj, settings and files
target Target 1 (MCS-51)
  device: A94B114 ABOV Semiconductor
  cpu: IRAM(0x00 - 0xFF) XRAM(0x0000-0x1FFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: HTY-21024-SM1503_V02_20210816 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SM1503_ABOV_S
  group Source Group 1
    ./: STARTUP.A51 Main.C PIC_OS_8.C
